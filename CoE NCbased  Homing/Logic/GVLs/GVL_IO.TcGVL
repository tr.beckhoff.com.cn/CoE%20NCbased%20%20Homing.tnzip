{attribute 'qualified_only'}
VAR_GLOBAL
	nDriverDigtalIn	AT %I* : UDINT;
END_VAR
